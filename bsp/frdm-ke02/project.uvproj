# Keil uVision project project.uvproj, settings and files
target RT-Thread (ARM-ADS)
  device: MKE02Z64xxx2 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: rt-thread-ke02 +hex
  AfterMake: fromelf.exe --bin -o .\build\rtthread.bin .\build\rt-thread-ke02.axf
  c flags: Optim=2
  c define: KEIL FRDM_KE02  CPU_KE02 CMSIS
  c include: applications;.;board;device;device\lib\inc;..\..\include;..\..\libcpu\arm\cortex-m0;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  group Applications
    applications/: application.c startup.c
  group Board
    board/: board.c drv_uart.c led.c
  group Device
    device/lib/drivers/: acmp.c adc.c arm_cm0.c crc.c flash.c ftm.c gpio.c i2c.c ics.c kbi.c memtest.c pit.c pmc.c queue.c rtc.c sim.c spi.c start.c startup.c sysinit.c systick.c uart.c wdog.c
    device/startup_keil/: startup_MKE02Z2.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
