# Keil uVision project template.uvproj, settings and files
target RT-Thread (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: rt-thread-k20d +hex
  AfterMake: fromelf.exe --bin -o .\build\rtthread.bin .\build\rt-thread-k20d.axf
  c flags: Optim=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
